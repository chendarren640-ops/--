# Keil uVision project 2026CLAUDE_APP.uvprojx, settings and files
target 2026CLAUDE_APP (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: GD32F470VE GigaDevice
  pack: GigaDevice.GD32F4xx_DFP.3.0.3
  cpu: IRAM(0x20000000,0x030000) IRAM2(0x10000000,0x010000) IROM(0x08011000,0x020000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: 2026CLAUDE_APP
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,GD32F470
  c include: ..\CMSIS;..\Startup;..\Library\GD32F4xx_standard_peripheral\Include;..\User;..\HardWare\LED;..\HardWare\OLED;..\HardWare\USART;..\HardWare\ADC;..\HardWare\DAC;..\HardWare\RTC;..\HardWare\Flash;..\HardWare\PT100;..\HardWare\KEY;..\Protocol;..\Function;..\CMSIS\GD\GD32F4xx\Include
  library: MicroLIB
  memory RVCT4: ROM 0x8011000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: .\APP_debug.sct
  group User
    ../User/: main.c main.h gd32f4xx_it.c gd32f4xx_it.h systick.c systick.h gd32f4xx_libopt.h
  group Driver
    ../HardWare/LED/: led_drv.c led_drv.h
    ../HardWare/OLED/: oled_drv.c oled_drv.h OLEDfont.h
    ../HardWare/USART/: usart_drv.c usart_drv.h usart0_dbg.c usart0_dbg.h
    ../HardWare/ADC/: adc_drv.c adc_drv.h
    ../HardWare/DAC/: dac_drv.c dac_drv.h
    ../HardWare/RTC/: rtc_drv.c rtc_drv.h
    ../HardWare/Flash/: flash_param.c flash_param.h
    ../HardWare/PT100/: pt100_drv.c pt100_drv.h
    ../HardWare/KEY/: key_drv.c key_drv.h
  group Protocol
    ../Protocol/: ascii_proto.c ascii_proto.h crc16.c crc16.h frame_parser.c frame_parser.h frame_builder.c frame_builder.h
  group Function
    ../Function/: sys_init.c sys_init.h cmd_handler.c cmd_handler.h data_channel.c data_channel.h param_mgr.c param_mgr.h alarm_mgr.c alarm_mgr.h
  group CMSIS
    ../CMSIS/GD/GD32F4xx/Source/: system_gd32f4xx.c
  group Library
    ../Library/GD32F4xx_standard_peripheral/Source/: gd32f4xx_adc.c gd32f4xx_crc.c gd32f4xx_dac.c gd32f4xx_dma.c gd32f4xx_exti.c gd32f4xx_fmc.c gd32f4xx_fwdgt.c gd32f4xx_gpio.c gd32f4xx_i2c.c gd32f4xx_misc.c gd32f4xx_pmu.c gd32f4xx_rcu.c gd32f4xx_rtc.c gd32f4xx_spi.c gd32f4xx_syscfg.c gd32f4xx_timer.c gd32f4xx_usart.c gd32f4xx_wwdgt.c
  group Startup
    ../Startup/: startup_gd32f450_470.s
software components: CMSIS:CORE 5.1.1
