# Keil uVision project CIMC_GD32_Template.uvprojx, settings and files
target CIMC_GD32_Template (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: GD32F470VE GigaDevice
  pack: GigaDevice.GD32F4xx_DFP.3.0.3
  cpu: IRAM(0x20000000,0x030000) IRAM2(0x10000000,0x010000) IROM(0x08000000,0x080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: CIMC_GD32_Template
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,GD32F470
  c include: ..\CMSIS;..\Startup;..\Library\GD32F4xx_standard_peripheral\Include;..\User;..\HeaderFiles;..\Function;..\CMSIS\GD\GD32F4xx\Include;..\Function\app_alarm;..\Function\app_autoreport;..\Function\app_param;..\Function\app_sample;..\Function\app_sleep;..\Driver\ADC;..\Driver\bsp_i2c;..\Driver\DAC;..\Driver\flash;..\Driver\gd30ad3340;..\Driver\LED;..\Driver\OLED;..\Driver\pt100;..\Driver\usart_rs485;..\Protocol\ascii_hex;..\Protocol\cmd;..\Protocol\crc;..\Driver\rtc;..\Function\app_alarm
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group User
    ../User/: gd32f4xx_it.c main.c systick.c
  group Driver
    ../Driver/LED/: LED.c LED.h
    ../Driver/OLED/: OLED.c OLED.h OLEDfont.h
    ../Driver/ADC/: bsp_adc.c bsp_adc.h
    ../Driver/DAC/: bsp_dac.c bsp_dac.h
    ../Driver/bsp_i2c/: bsp_i2c.c bsp_i2c.h
    ../Driver/gd30ad3340/: gd30ad3340.c gd30ad3340.h
    ../Driver/pt100/: pt100.c pt100.h
    ../Driver/flash/: bsp_flash.c bsp_flash.h
    ../Driver/usart_rs485/: bsp_usart_rs485.c bsp_usart_rs485.h
    ../Driver/rtc/: bsp_rtc.c bsp_rtc.h
  group Protocol
    ../Protocol/ascii_hex/: protocol_ascii_hex.c protocol_ascii_hex.h
    ../Protocol/cmd/: protocol_cmd.c protocol_cmd.h
    ../Protocol/crc/: protocol_crc.c protocol_crc.h
  group Function
    ../Function/: Function.c Function.h
    ../Function/app_param/: app_param.c app_param.h
    ../Function/app_sample/: app_sample.c app_sample.h
    ../Function/app_alarm/: app_alarm.c app_alarm.h
    ../Function/app_autoreport/: app_autoreport.c app_autoreport.h
    ../Function/app_sleep/: app_sleep.c app_sleep.h
  group HeaderFiles
    ../HeaderFiles/: HeaderFiles.h
  group CMSIS
    ../CMSIS/GD/GD32F4xx/Source/: system_gd32f4xx.c
  group Library
    ../Library/GD32F4xx_standard_peripheral/Source/: gd32f4xx_adc.c gd32f4xx_can.c gd32f4xx_crc.c gd32f4xx_ctc.c gd32f4xx_dac.c gd32f4xx_dbg.c gd32f4xx_dci.c gd32f4xx_dma.c gd32f4xx_enet.c gd32f4xx_exmc.c gd32f4xx_exti.c gd32f4xx_fmc.c gd32f4xx_fwdgt.c gd32f4xx_gpio.c gd32f4xx_i2c.c gd32f4xx_ipa.c gd32f4xx_iref.c gd32f4xx_misc.c gd32f4xx_pmu.c gd32f4xx_rcu.c gd32f4xx_rtc.c gd32f4xx_sdio.c gd32f4xx_spi.c gd32f4xx_syscfg.c gd32f4xx_timer.c gd32f4xx_tli.c gd32f4xx_trng.c gd32f4xx_usart.c gd32f4xx_wwdgt.c
  group Startup
    ../CMSIS/GD/GD32F4xx/Source/ARM/: startup_gd32f450_470.s
  group Readme
    ../01 Readme/: Readme.txt
software components: CMSIS:CORE 5.1.1
