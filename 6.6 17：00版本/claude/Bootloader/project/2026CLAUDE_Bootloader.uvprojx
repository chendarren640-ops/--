# Keil uVision project 2026CLAUDE_Bootloader.uvprojx, settings and files
target 2026CLAUDE_Bootloader (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: GD32F470VE GigaDevice
  pack: GigaDevice.GD32F4xx_DFP.3.0.3
  cpu: IRAM(0x20000000,0x030000) IRAM2(0x10000000,0x010000) IROM(0x08000000,0x010000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: 2026CLAUDE_Bootloader
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,GD32F470
  c include: ..\CMSIS;..\Startup;..\Library\GD32F4xx_standard_peripheral\Include;..\Driver;..\CMSIS\GD\GD32F4xx\Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group User
    ../: main.c bootloader.h gd32f4xx_libopt.h
  group Driver
    ../Driver/: systick_bl.c systick_bl.h led_bl.c led_bl.h oled_bl.c oled_bl.h usart1_bl.c usart1_bl.h flash_bl.c flash_bl.h ota_handler.c ota_handler.h
  group CMSIS
    ../CMSIS/GD/GD32F4xx/Source/: system_gd32f4xx.c
  group Library
    ../Library/GD32F4xx_standard_peripheral/Source/: gd32f4xx_gpio.c gd32f4xx_rcu.c gd32f4xx_misc.c gd32f4xx_pmu.c gd32f4xx_fmc.c gd32f4xx_usart.c
  group Startup
    ../Startup/: startup_gd32f450_470.s
software components: CMSIS:CORE 5.1.1
