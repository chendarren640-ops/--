/**
 * @file    protocol_utils.c
 * @brief   通信协议层工具实现
 *
 * 赛题核心规约:
 *   "所有协议帧按十六进制结构组帧后, 以组帧后的ASCII字符串形式在串口收发,
 *    不要通过Hex发送。"
 *   例如帧头为 0xA5B6, 则直接发送 A5B6 的字符(0x41 0x35 0x42 0x36),
 *   而不是十六进制形式(0xA5 0xB6)。
 */

#include "protocol_utils.h"

/* CRC16 查表 - 多项式 0x1021 (常用Modbus CRC) */
static const uint16_t crc16_table[256] = {
    0x0000, 0x1021, 0x2042, 0x3063, 0x4084, 0x50A5, 0x60C6, 0x70E7,
    0x8108, 0x9129, 0xA14A, 0xB16B, 0xC18C, 0xD1AD, 0xE1CE, 0xF1EF,
    0x1231, 0x0210, 0x3273, 0x2252, 0x52B5, 0x4294, 0x72F7, 0x62D6,
    0x9339, 0x8318, 0xB37B, 0xA35A, 0xD3BD, 0xC39C, 0xF3FF, 0xE3DE,
    0x2462, 0x3443, 0x0420, 0x1401, 0x64E6, 0x74C7, 0x44A4, 0x5485,
    0xA56A, 0xB54B, 0x8528, 0x9509, 0xE5EE, 0xF5CF, 0xC5AC, 0xD58D,
    0x3653, 0x2672, 0x1611, 0x0630, 0x76D7, 0x66F6, 0x5695, 0x46B4,
    0xB75B, 0xA77A, 0x9719, 0x8738, 0xF7DF, 0xE7FE, 0xD79D, 0xC7BC,
    0x48C4, 0x58E5, 0x6886, 0x78A7, 0x0840, 0x1861, 0x2802, 0x3823,
    0xC9CC, 0xD9ED, 0xE98E, 0xF9AF, 0x8948, 0x9969, 0xA90A, 0xB92B,
    0x5AF5, 0x4AD4, 0x7AB7, 0x6A96, 0x1A71, 0x0A50, 0x3A33, 0x2A12,
    0xDBFD, 0xCBDC, 0xFBBF, 0xEB9E, 0x9B79, 0x8B58, 0xBB3B, 0xAB1A,
    0x6CA6, 0x7C87, 0x4CE4, 0x5CC5, 0x2C22, 0x3C03, 0x0C60, 0x1C41,
    0xEDAE, 0xFD8F, 0xCDEC, 0xDDCD, 0xAD2A, 0xBD0B, 0x8D68, 0x9D49,
    0x7E97, 0x6EB6, 0x5ED5, 0x4EF4, 0x3E13, 0x2E32, 0x1E51, 0x0E70,
    0xFF9F, 0xEFBE, 0xDFDD, 0xCFFC, 0xBF1B, 0xAF3A, 0x9F59, 0x8F78,
    0x9188, 0x81A9, 0xB1CA, 0xA1EB, 0xD10C, 0xC12D, 0xF14E, 0xE16F,
    0x1080, 0x00A1, 0x30C2, 0x20E3, 0x5004, 0x4025, 0x7046, 0x6067,
    0x83B9, 0x9398, 0xA3FB, 0xB3DA, 0xC33D, 0xD31C, 0xE37F, 0xF35E,
    0x02B1, 0x1290, 0x22F3, 0x32D2, 0x4235, 0x5214, 0x6277, 0x7256,
    0xB5EA, 0xA5CB, 0x95A8, 0x8589, 0xF56E, 0xE54F, 0xD52C, 0xC50D,
    0x34E2, 0x24C3, 0x14A0, 0x0481, 0x7466, 0x6447, 0x5424, 0x4405,
    0xA7DB, 0xB7FA, 0x8799, 0x97B8, 0xE75F, 0xF77E, 0xC71D, 0xD73C,
    0x26D3, 0x36F2, 0x0691, 0x16B0, 0x6657, 0x7676, 0x4615, 0x5634,
    0xD94C, 0xC96D, 0xF90E, 0xE92F, 0x99C8, 0x89E9, 0xB98A, 0xA9AB,
    0x5844, 0x4865, 0x7806, 0x6827, 0x18C0, 0x08E1, 0x3882, 0x28A3,
    0xCB7D, 0xDB5C, 0xEB3F, 0xFB1E, 0x8BF9, 0x9BD8, 0xABBB, 0xBB9A,
    0x4A75, 0x5A54, 0x6A37, 0x7A16, 0x0AF1, 0x1AD0, 0x2AB3, 0x3A92,
    0xFD2E, 0xED0F, 0xDD6C, 0xCD4D, 0xBDAA, 0xAD8B, 0x9DE8, 0x8DC9,
    0x7C26, 0x6C07, 0x5C64, 0x4C45, 0x3CA2, 0x2C83, 0x1CE0, 0x0CC1,
    0xEF1F, 0xFF3E, 0xCF5D, 0xDF7C, 0xAF9B, 0xBFBA, 0x8FD9, 0x9FF8,
    0x6E17, 0x7E36, 0x4E55, 0x5E74, 0x2E93, 0x3EB2, 0x0ED1, 0x1EF0
};

/**
 * @brief 计算 CRC16
 * @param data  数据指针
 * @param len   数据长度
 * @return 16位 CRC 值
 */
uint8_t calc_crc16(uint8_t *data, uint16_t len)
{
    uint16_t crc = 0xFFFF;
    while(len--) {
        crc = (crc << 8) ^ crc16_table[((crc >> 8) ^ *data++) & 0xFF];
    }
    /* 返回 CRC 低8位和高8位 */
    return (uint8_t)(crc & 0xFF);
}

/**
 * @brief 单字节转十六进制字符串 (如 0xA5 -> "A5")
 * @param byte     输入字节
 * @param hex_str  输出字符串 (至少3字节, 含'\0')
 */
void byte_to_hex_str(uint8_t byte, char *hex_str)
{
    static const char hex_table[] = "0123456789ABCDEF";
    hex_str[0] = hex_table[(byte >> 4) & 0x0F];
    hex_str[1] = hex_table[byte & 0x0F];
    hex_str[2] = '\0';
}

/**
 * @brief 将十六进制数组转为 ASCII 字符串
 * @note  赛题核心函数: 帧数据必须经此函数转换后再发送
 * @param hex_data  输入十六进制数组
 * @param hex_len   输入长度
 * @param str_out   输出字符串 (需预分配 hex_len*2+1 字节)
 */
void hex_to_str(uint8_t *hex_data, uint16_t hex_len, char *str_out)
{
    uint16_t i;
    for(i = 0; i < hex_len; i++) {
        byte_to_hex_str(hex_data[i], &str_out[i * 2]);
    }
    str_out[hex_len * 2] = '\0';
}

/**
 * @brief 十六进制字符转数值 (如 'A' -> 0x0A)
 */
uint8_t hex_char_to_byte(char c)
{
    if(c >= '0' && c <= '9') return (uint8_t)(c - '0');
    if(c >= 'A' && c <= 'F') return (uint8_t)(c - 'A' + 10);
    if(c >= 'a' && c <= 'f') return (uint8_t)(c - 'a' + 10);
    return 0;
}

/**
 * @brief ASCII 字符串转十六进制数组
 * @param str     输入 ASCII 字符串 (如 "A5B6")
 * @param hex_out 输出十六进制数组
 * @param max_len 最大输出字节数
 * @return 实际转换字节数
 */
uint8_t str_to_hex(const char *str, uint8_t *hex_out, uint16_t max_len)
{
    uint16_t i = 0, len;
    len = (uint16_t)strlen(str);
    if(len % 2) return 0; /* 长度必须为偶数 */

    for(i = 0; i < len / 2 && i < max_len; i++) {
        hex_out[i] = (uint8_t)(hex_char_to_byte(str[i * 2]) << 4)
                   | hex_char_to_byte(str[i * 2 + 1]);
    }
    return (uint8_t)i;
}
